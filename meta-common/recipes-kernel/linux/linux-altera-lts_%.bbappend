COMPATIBLE_MACHINE_${MACHINE} = "de0-nano"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"


LINUX_VERSION_EXTENSION = "-${CI_VERSION}"

